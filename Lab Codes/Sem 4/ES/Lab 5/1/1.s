	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =DST
	LDR R1, =SRC
	MOV R3,#10
LOOP0
	LDR R2, [R1], #4
	STR R2, [R0], #4
	SUBS R3, #1
	TEQ R3, #0
	BNE LOOP0
	LDR R0, =DST
	MOV R3,#9
LOOP1
	ADD R5,R0,#4
	LDR R1,[R0]
	MOV R6,R3
	MOV R4,R0
	MOV R7,R1
LOOP2
	LDR R2,[R5]
	CMP R1,R2
	BLO SKIP
	MOV R1,R2
	MOV R4,R5
SKIP
	ADD R5,#4
	SUBS R6,#1
	BNE LOOP2
	STR R1,[R0]
	STR R7,[R4]
	ADD R0,#4
	SUBS R3,#1
	BNE LOOP1
	NOP 
SRC DCD 0xA,0x9,0x8,0x7,0x6,0x5,0x4,0x3,0x2,0x1
	AREA mydata, DATA, READWRITE
DST DCD 0
	END