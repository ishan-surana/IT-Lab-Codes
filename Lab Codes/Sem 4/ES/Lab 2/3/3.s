	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x40001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	MOV R0, #1
	LDR R1, VALUE1
	LDR R2, VALUE2
	MUL R3, R1, R2
HCF_Loop
	CMP R1, R2
	SUBHI R1, R1, R2
	SUBLO R2, R2, R1
	BNE HCF_Loop
	MOV R4, #0 ;counter
LCM_Gen
	ADDS R4, #1
	SUBS R3, R2
	TEQ R3, #0
	BNE LCM_Gen
STOP
	B STOP
VALUE1 DCD 0x150 ;336
VALUE2 DCD 0x13BC ;5052  ANS=141456 [0x22890]
	AREA data, DATA, READWRITE
	END