# Keil uVision project 2.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lab 1
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: 2.s
software components: CMSIS:CORE 6.0.0
